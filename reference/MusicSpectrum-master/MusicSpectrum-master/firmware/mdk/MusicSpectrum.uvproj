# Keil uVision project MusicSpectrum.uvproj, settings and files
target MusicSpectrum (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: MusicSpectrum +hex
  AfterMake: fromelf --bin !L --output MusicSpectrum.bin
  c flags: Optim=4 oTime=1 v6Lang=1 v6LangP=1
  c define: STM32F401xx,USE_STDPERIPH_DRIVER
  c misc: --c99;
  c include: ..\driver\inc;..\framework;..\lib\CMSIS\STM32F4xx\Include;..\lib\CMSIS\Include;..\user;..\user\module;..\lib\STM32F4xx_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --keep *.o(init.item.*)
  group startup
    ../lib/CMSIS/STM32F4xx/Source/arm/: startup_stm32f4xx.s
  group driver
    ../driver/src/: led_matrix.c tty.c
  group framework
    ../framework/: cli.c module.c ringbuffer.c
  group CMSIS
    ../lib/CMSIS/STM32F4xx/Source/: system_stm32f4xx.c
  group StdPeriph_Driver
    ../lib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_iwdg.c
  group user
    ../user/: stm32f4xx_it.c spectrum.c cr2fft_512.c cr2fft_256.c cr2fft_128.c audio_sample.c main.c platform.c public.c
  group user/task
    ../user/task/: cli_task.c
  group user/cmd
    ../user/cmd/: cmd_fft.c cmd_devinfo.c
